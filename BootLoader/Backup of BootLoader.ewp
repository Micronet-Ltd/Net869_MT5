# IAR project Backup of BootLoader.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK20DX256xxx10 Freescale MK20DX256xxx10
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: _DEBUG=1; CPU_MK20DX256VMC10=1
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: BootLoader.srec
  ILINK.IlinkOutputFile: BootLoader.out
  ILINK.IlinkConfigDefines: __ram_vector_table__=1; __stack_size__=0x4000; __heap_size__=0x8000
  ILINK.IlinkIcfFile: linker\MK20DX256xxx10_flash.icf
  ILINK.IlinkAdditionalLibs: ..\MQX_OS\MQX_PSP\iar\Debug_IAR\lib_mqx.a
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ILINK.IlinkOutputFile: c.out
  ILINK.IlinkIcfFile: ..\MQX_OS\BSP\platform\devices\MK20D10\linker\iar\MK20DX256xxx10_flash.icf
  ILINK.IlinkAdditionalLibs: ..\MQX_OS\MQX_PSP\iar\Release_IAR\lib_mqx.a
  group (top)
    ./: main.c
  group KSDK Files
    ../MQX_OS/BSP/platform/devices/MK20D10/startup/iar/: startup_MK20D10.s
