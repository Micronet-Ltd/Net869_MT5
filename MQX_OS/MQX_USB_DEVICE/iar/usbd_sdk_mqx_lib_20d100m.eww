<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/usbd_sdk_mqx_lib_20d100m.ewp</path>
  </project>
</workspace>
