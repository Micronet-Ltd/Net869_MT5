# IAR project usbd_sdk_mqx_lib_20d100m.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK20DX256xxx10 Freescale MK20DX256xxx10
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: _DEBUG=1; CPU_MK20DX256VMC10; FSL_RTOS_MQX
  ICCARM.CCDiagSuppress: Pa039,Pe068,Pe069,Pa082,Pe177,Pe186,Pe550,Pa050
  ICCARM.CCIncludePath2: ..\..\BSP\rtos\mqx\mqx\source\psp\cortex_m\compiler\iar; ..\..\BSP\rtos; ..\..\BSP\rtos\mqx\config\common; ..\..\rtos\mqx\config\mcu\MK20D10; ..\..\BSP\rtos\mqx\mqx\source\include; ..\..\BSP\rtos\mqx\mqx\source\psp\cortex_m; ..\..\BSP\usb\adapter\sources; ..\..\BSP\usb\adapter\sources\sdk; ..\..\BSP\usb\usb_core\include; ..\..\BSP\usb\usb_core\device\include; ..\..\BSP\usb\usb_core\device\sources\classes\audio; ..\..\BSP\usb\usb_core\device\sources\classes\cdc; ..\..\BSP\usb\usb_core\device\sources\classes\common; ..\..\BSP\usb\usb_core\device\sources\classes\composite; ..\..\BSP\usb\usb_core\device\sources\classes\hid; ..\..\BSP\usb\usb_core\device\sources\classes\include; ..\..\BSP\usb\usb_core\device\sources\classes\include\config; ..\..\BSP\usb\usb_core\device\sources\classes\msd; ..\..\BSP\usb\usb_core\device\sources\classes\phdc; ..\..\BSP\usb\usb_core\device\sources\classes\video; ..\..\BSP\usb\usb_core\device\sources\controller; ..\..\BSP\usb\usb_core\device\sources\controller\khci; ..\..\BSP\usb\usb_core\device\sources\controller\ehci; ..\..\BSP\usb\usb_core\hal; ..\..\BSP\platform\osa\inc; ..\..\BSP\platform\utilities\inc; ..\..\BSP\platform\CMSIS\Include; ..\..\BSP\platform\devices; ..\..\BSP\platform\system\inc; ..\..\BSP\platform\hal\inc; ..\..\BSP\platform\drivers\inc; ..\..\BSP\platform\devices\MK20D10\include; ..\..\BSP\platform\devices\MK20D10\startup; ..\..\BSP\platform\devices\MK20D10; ..\..\usb\usb_core\device\include\net869
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.ADefines: DEBUG
  ILINK.IlinkOutputFile: psp_arm.out
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: _DEBUG=0; CPU_MK20DX256VMC10; FSL_RTOS_MQX
  ICCARM.CCOptLevel: 3
  ILINK.IlinkOutputFile: libgeneric.out
  group adapter
    ../../BSP/usb/adapter/sources/: adapter.h adapter_types.h
  group adapter/sdk
    ../../BSP/usb/adapter/sources/sdk/: adapter_cfg.h adapter_sdk.c adapter_sdk.h
  group usb_core/device/include
    ../../usb/usb_core/device/include/net869/: usb_device_config.h
    ../../BSP/usb/usb_core/device/include/: usb_device_stack_interface.h
  group usb_core/device/sources/bsp
    ../../usb/usb_core/device/sources/bsp/net869/: usb_dev_bsp.c
  group usb_core/device/sources/class driver/audio
    ../../BSP/usb/usb_core/device/sources/classes/audio/: usb_audio.c usb_audio.h
  group usb_core/device/sources/class driver/cdc
    ../../BSP/usb/usb_core/device/sources/classes/cdc/: usb_cdc.c usb_cdc.h usb_cdc_pstn.c usb_cdc_pstn.h
  group usb_core/device/sources/class driver/common
    ../../BSP/usb/usb_core/device/sources/classes/common/: usb_class.c usb_class_internal.h
  group usb_core/device/sources/class driver/composite
    ../../BSP/usb/usb_core/device/sources/classes/composite/: usb_composite.c usb_composite.h
  group usb_core/device/sources/class driver/hid
    ../../BSP/usb/usb_core/device/sources/classes/hid/: usb_hid.c usb_hid.h
  group usb_core/device/sources/class driver/include
    ../../BSP/usb/usb_core/device/sources/classes/include/: usb_class.h usb_class_audio.h usb_class_cdc.h usb_class_composite.h usb_class_hid.h usb_class_msc.h usb_class_phdc.h usb_class_video.h
  group usb_core/device/sources/class driver/msd
    ../../BSP/usb/usb_core/device/sources/classes/msd/: usb_msc.c usb_msc.h usb_msc_scsi.c usb_msc_scsi.h
  group usb_core/device/sources/class driver/phdc
    ../../BSP/usb/usb_core/device/sources/classes/phdc/: usb_phdc.c usb_phdc.h
  group usb_core/device/sources/class driver/video
    ../../BSP/usb/usb_core/device/sources/classes/video/: usb_video.c usb_video.h
  group usb_core/device/sources/controller driver
    ../../BSP/usb/usb_core/device/sources/controller/: usb_dev.c usb_dev.h usb_framework.c usb_framework.h
  group usb_core/device/sources/controller driver/khci
    ../../BSP/usb/usb_core/device/sources/controller/khci/: device_khci_interface.c khci_dev.c khci_dev.h khci_dev_misc.h
  group usb_core/include
    ../../BSP/usb/usb_core/include/: compiler.h types.h usb.h usb_desc.h usb_error.h usb_misc.h usb_opt.h usb_types.h
