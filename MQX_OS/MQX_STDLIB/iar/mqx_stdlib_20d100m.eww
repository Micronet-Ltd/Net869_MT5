<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\mqx_stdlib_20d100m.ewp</path>
  </project>
  <batchBuild/>
</workspace>


