# IAR project mqx_stdlib_20d100m.ewp, settings and files
configuration debug (ARM, debug)
  General.OGChipSelectEditMenu: MK20DX256xxx10 Freescale MK20DX256xxx10
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: CPU_MK20DX256VMC10=1; FSL_RTOS_MQX=1; _DEBUG=1
  ICCARM.CCDiagSuppress: Pa082,Pe186
  ICCARM.CCIncludePath2: ..\..\BSP\rtos\mqx\mqx_stdlib\source\include; ..\..\BSP\rtos\mqx\mqx_stdlib\source\stdio; ..\..\BSP\rtos\mqx\mqx\source\psp\cortex_m\compiler\iar; ..\..\BSP\rtos\mqx\mqx\source\psp\cortex_m; ..\..\BSP\rtos\mqx\mqx\source\psp\cortex_m\cpu; ..\..\BSP\platform\devices\MK20D10\startup; ..\..\BSP\platform\CMSIS\Include; ..\..\BSP\rtos\mqx\config\common; ..\..\rtos\mqx\config\mcu\MK20D10; ..\..\rtos\mqx\config\board\net869; ..\..\BSP\platform\devices\MK20D10; ..\..\BSP\rtos\mqx\mqx\source\include; ..\..\BSP\rtos\mqx\mqx\source\nio; ..\..\BSP\mqx\mqx\source\nio\src; ..\..\BSP\mqx\mqx\source\nio\fs; ..\..\BSP\mqx\mqx\source\nio\drivers\nio_dummy; ..\..\BSP\mqx\mqx\source\nio\drivers\nio_mem; ..\..\BSP\mqx\mqx\source\nio\drivers\nio_null; ..\..\BSP\mqx\mqx\source\nio\drivers\nio_pipe; ..\..\BSP\mqx\mqx\source\nio\drivers\nio_serial; ..\..\BSP\mqx\mqx\source\nio\drivers\nio_tfs; ..\..\BSP\mqx\mqx\source\nio\drivers\nio_tty; ..\..\BSP\platform\devices\MK20D10\startup; ..\..\BSP\mqx\mqx\source\tad; ..\..\BSP\mqx\mqx\source\include; ..\..\BSP\platform\devices\MK20D10\startup; ..\..\BSP\platform\devices\MK20D10\include; ..\..\BSP\platform; ..\..\BSP\platform\devices; ..\..\BSP\platform\CMSIS\Include; ..\..\BSP\platform\hal\inc; ..\..\BSP\platform\drivers\inc; ..\..\BSP\platform\drivers\src\mpu; ..\..\BSP\platform\drivers\src\uart; ..\..\BSP\platform\utilities\inc; ..\..\BSP\middleware\filesystem\mfs\source\mfs_sdcard\nio_esdhc; ..\..\BSP; ..\..\BSP\platform\osa\inc; ..\..\BSP\platform\system\inc
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.ADefines: CPU_MK20DX256VMC10=1; FSL_RTOS_MQX=1; _DEBUG=1
  AARM.AUserIncludes: ..\..\BSP\mqx\mqx\source\psp\cortex_m\compiler\iar; ..\..\BSP\mqx\mqx\source\psp\cortex_m\core\M4; ..\..\BSP\mqx\mqx\source\psp\cortex_m; ..\..\BSP\platform\devices\MK20D10\startup; ..\..\rtos\mqx\config\mcu\MK20D10; ..\..\rtos\mqx\config\board\net869; ..\..\BSP\platform\devices\MK20D10; ..\..\BSP\rtos\mqx\mqx\source\include; ..\..\BSP\config\common; ..\..\BSP\platform\devices\MK20D10\startup; ..\..\BSP\platform\devices\MK20D10\include
  ILINK.IlinkOutputFile: psp_arm.out
configuration release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: CPU_MK20DX256VMC10=1; FSL_RTOS_MQX=1; NDEBUG=1
  ICCARM.CCOptLevel: 3
  AARM.ADefines: CPU_MK20DX256VMC10=1; FSL_RTOS_MQX=1; NDEBUG=1
  ILINK.IlinkOutputFile: libgeneric.out
  group mqx_stdlib Source/include
    ../../BSP/rtos/mqx/mqx_stdlib/source/include/: std_prv.h stdio.h strings.h
  group mqx_stdlib Source/mqx_stdio
    ../../BSP/rtos/mqx/mqx_stdlib/source/stdio/: buf_prv.c buf_prv.h err.c fclose.c fflush.c fopen.c fp_prv.c fp_prv.h fread.c fwrite.c get.c pos.c print.c print_prv.c print_prv.h put.c scan.c scan_prv.c scan_prv.h stdio.c
  group mqx_stdlib Source/mqx_strings
    ../../BSP/rtos/mqx/mqx_stdlib/source/strings/: strings.c
