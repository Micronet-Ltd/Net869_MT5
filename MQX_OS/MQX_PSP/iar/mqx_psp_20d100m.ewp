# IAR project mqx_psp_20d100m.ewp, settings and files
configuration debug (ARM, debug)
  General.OGChipSelectEditMenu: MK20DX256xxx10 Freescale MK20DX256xxx10
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: CPU_MK20DX256VMC10=1; FSL_RTOS_MQX=1; MQX_DISABLE_CONFIG_CHECK=1; _DEBUG=1
  ICCARM.CCDiagSuppress: Pa082,Pe186
  ICCARM.CCIncludePath2: ..\..\BSP\rtos\mqx\mqx\source\psp\cortex_m\compiler\iar; ..\..\BSP\rtos\mqx\mqx\source\psp\cortex_m; ..\..\BSP\rtos\mqx\mqx\source\psp\cortex_m\cpu; ..\..\BSP\platform\devices\MK20D10\startup; ..\..\BSP\platform\CMSIS\Include; ..\..\BSP\rtos\mqx\config\common; ..\..\rtos\mqx\config\mcu\MK20D10; ..\..\rtos\mqx\config\board\net869; ..\..\BSP\platform\devices\MK20D10; ..\..\BSP\rtos\mqx\mqx\source\include; ..\..\BSP\rtos\mqx\mqx\source\nio; ..\..\BSP\rtos\mqx\mqx\source\nio\src; ..\..\BSP\rtos\mqx\mqx\source\nio\fs; ..\..\BSP\rtos\mqx\mqx\source\nio\drivers\nio_dummy; ..\..\BSP\rtos\mqx\mqx\source\nio\drivers\nio_mem; ..\..\BSP\rtos\mqx\mqx\source\nio\drivers\nio_null; ..\..\BSP\rtos\mqx\mqx\source\nio\drivers\nio_pipe; ..\..\BSP\rtos\mqx\mqx\source\nio\drivers\nio_serial; ..\..\BSP\rtos\mqx\mqx\source\nio\drivers\nio_tfs; ..\..\BSP\rtos\mqx\mqx\source\nio\drivers\nio_tty; ..\..\BSP\platform\devices\MK20D10\startup; ..\..\BSP\rtos\mqx\mqx\source\tad; ..\..\BSP\rtos\mqx\mqx\source\include; ..\..\BSP\rtos\mqx\mqx_stdlib\source\include; ..\..\BSP\rtos\mqx\mqx_stdlib\source\stdio; ..\..\BSP\platform\devices\MK20D10/startup; ..\..\BSP\platform\devices/MK20D10/include; ..\..\BSP\platform; ..\..\BSP\platform\devices; ..\..\BSP\platform\CMSIS\Include; ..\..\BSP\platform\hal\inc; ..\..\BSP\platform\drivers/inc; ..\..\BSP\platform\drivers/src/mpu; ..\..\BSP\platform\drivers/src/uart; ..\..\BSP\platform\utilities/inc; ..\..\BSP\middleware\filesystem\mfs\source\mfs_sdcard\nio_esdhc; ..\..\BSP; ..\..\BSP\platform\osa\inc; ..\..\BSP\platform\system\inc
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.ADefines: as above
  AARM.AUserIncludes: ..\..\BSP\rtos\mqx\mqx\source\psp\cortex_m\compiler\iar; ..\..\BSP\rtos\mqx\mqx\source\psp\cortex_m\core\M4; ..\..\BSP\rtos\mqx\mqx\source\psp\cortex_m; ..\..\BSP\platform\devices\MK20D10\startup; ..\..\rtos\mqx\config\mcu\MK20D10; ..\..\rtos\mqx\config\board\net869; ..\..\BSP\platform\devices\MK20D10; ..\..\BSP\rtos\mqx\mqx\source\include; ..\..\BSP\rtos\mqx\config\common; ..\..\BSP\platform\devices\MK20D10\startup; ..\..\BSP\platform\devices\MK20D10\startup; ..\..\BSP\platform\devices\MK20D10\include
  ILINK.IlinkOutputFile: psp_arm.out
configuration release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: CPU_MK20DX256VMC10=1; FSL_RTOS_MQX=1; MQX_DISABLE_CONFIG_CHECK=1; NDEBUG=1
  ICCARM.CCOptLevel: 3
  AARM.ADefines: as above
  ILINK.IlinkOutputFile: libgeneric.out
  group CMSIS
    ../../BSP/platform/CMSIS/Include/: core_cm4.h core_cmFunc.h core_cmInstr.h core_cmSimd.h
  group Config Files
    ../../BSP/rtos/mqx/config/common/: lite_config.h mqx_cnfg.h small_ram_config.h verif_enabled_config.h
    ../../rtos/mqx/config/mcu/MK20D10/: mqx_sdk_config.h
    ../../rtos/mqx/config/board/net869/: user_config.h
  group KSDK Files
    ../../BSP/platform/devices/: startup.c
    ../../BSP/platform/devices/MK20D10/startup/iar/: startup_MK20D10.s
    ../../BSP/platform/devices/MK20D10/startup/: system_MK20D10.c system_MK20D10.h
  group MQX Generic/include
    ../../BSP/rtos/mqx/mqx/source/psp/cortex_m/compiler/iar/: asm_mac.h comp.c comp.h
    ../../BSP/rtos/mqx/mqx/source/include/: charq.h eds.h eds_prv.h edserial.h edserprv.h event.h event_prv.h gen_rev.h klog.h log.h log_prv.h lwevent.h lwevent_prv.h lwlog.h lwlog_prv.h lwmem.h lwmem_prv.h lwmsgq.h lwmsgq_prv.h lwsem.h lwtimer.h lwtimer_prv.h mem_prv.h message.h mmu.h mqx.h mqx_cpudef.h mqx_inc.h mqx_ioc.h mqx_macros.h mqx_prv.h mqx_str.h msg_prv.h mutex.h mutex_prv.h name.h name_prv.h partition.h partition_prv.h pcb.h queue.h sem.h sem_prv.h timer.h timer_prv.h tlsf.h tlsf_adaptation.h tlsf_adaptation_prv.h tlsfbits.h watchdog.h watchdog_prv.h
  group MQX Generic/kernel
    ../../BSP/rtos/mqx/mqx/source/kernel/: event.c idletask.c inittask.c int.c klog.c log.c lwevent.c lwlog.c lwmem.c lwmsgq.c lwsem.c lwtimer.c mem.c mqx.c msg.c msgpool.c msgq.c mutex.c name.c partition.c queue.c sched.c sem.c task.c taskq.c time.c timer.c tlsf.c tlsf_adaptation.c watchdog.c
    ../../BSP/rtos/mqx/mqx/source/include/: task.h
  group MQX Generic/nio
    ../../BSP/rtos/mqx/mqx/source/nio/src/: errno.c nio.c nio_posix.c nio_prv.h nio_std_adpt.c
    ../../BSP/rtos/mqx/mqx/source/nio/: fcntl.h ioctl.h nio.h unistd.h
    ../../BSP/rtos/mqx/mqx/source/nio/fs/: fs_supp.c fs_supp.h
  group MQX Generic/string
    ../../BSP/rtos/mqx/mqx/source/string/: str_utos.c strnlen.c
  group MQX Generic/tad
    ../../BSP/rtos/mqx/mqx/source/tad/: tad.c tad.h
  group Peripheral NIO Drivers/nio_dummy
    ../../BSP/rtos/mqx/mqx/source/nio/drivers/nio_dummy/src/: nio_dummy.c
    ../../BSP/rtos/mqx/mqx/source/nio/drivers/nio_dummy/: nio_dummy.h
  group Peripheral NIO Drivers/nio_mem
    ../../BSP/rtos/mqx/mqx/source/nio/drivers/nio_mem/src/: nio_mem.c
    ../../BSP/rtos/mqx/mqx/source/nio/drivers/nio_mem/: nio_mem.h
  group Peripheral NIO Drivers/nio_null
    ../../BSP/rtos/mqx/mqx/source/nio/drivers/nio_null/src/: nio_null.c
    ../../BSP/rtos/mqx/mqx/source/nio/drivers/nio_null/: nio_null.h
  group Peripheral NIO Drivers/nio_pipe
    ../../BSP/rtos/mqx/mqx/source/nio/drivers/nio_pipe/src/: nio_pipe.c
    ../../BSP/rtos/mqx/mqx/source/nio/drivers/nio_pipe/: nio_pipe.h
  group Peripheral NIO Drivers/nio_serial
    ../../BSP/rtos/mqx/mqx/source/nio/drivers/nio_serial/src/: nio_serial.c
    ../../BSP/rtos/mqx/mqx/source/nio/drivers/nio_serial/: nio_serial.h
  group Peripheral NIO Drivers/nio_tfs
    ../../BSP/rtos/mqx/mqx/source/nio/drivers/nio_tfs/src/: nio_tfs.c
    ../../BSP/rtos/mqx/mqx/source/nio/drivers/nio_tfs/: nio_tfs.h
  group Peripheral NIO Drivers/nio_tty
    ../../BSP/rtos/mqx/mqx/source/nio/drivers/nio_tty/src/: nio_tty.c
    ../../BSP/rtos/mqx/mqx/source/nio/drivers/nio_tty/: nio_tty.h
  group PSP Cortex
    ../../BSP/rtos/mqx/mqx/source/psp/cortex_m/core/M4/: boot.S dispatch.S psp_prv.inc support.S
    ../../BSP/rtos/mqx/mqx/source/psp/cortex_m/: cortex.c cortex.h int_gkis.c int_kisr.c int_pvta.c int_unx.c int_vtab.c int_xcpt.c ipsum.c kinetis.h kinetis_mpu.h mem_copy.c mem_zero.c nvic.c nvic.h psp.h psp_abi.h psp_comp.h psp_cpu.h psp_dati.c psp_gelms.c psp_hoti.c psp_iinit.c psp_mat1.c psp_mat2.c psp_mat3.c psp_math.h psp_miti.c psp_msti.c psp_mstiq.c psp_nsti.c psp_prv.h psp_psti.c psp_rev.h psp_seti.c psp_supp.c psp_supp.h psp_tiad.c psp_tida.c psp_tihr.c psp_time.h psp_timn.c psp_tims.c psp_tinm.c psp_tins.c psp_tiol.c psp_tipr.c psp_tips.c psp_tise.c psp_tisu.c psp_tius.c psp_tkti.c psp_usti.c psptypes.h sc_irdyq.c stack_bu.c stack_de.c stack_st.c types.inc
    ../../BSP/rtos/mqx/mqx/source/psp/cortex_m/cpu/: kinetis_fcan.h
