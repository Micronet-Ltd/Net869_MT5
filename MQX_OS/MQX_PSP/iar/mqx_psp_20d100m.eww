<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\mqx_psp_20d100m.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>debug</name>
      <member>
        <project>mqx_twrk60d100m</project>
        <configuration>debug</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>release</name>
      <member>
        <project>mqx_twrk60d100m</project>
        <configuration>release</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>


