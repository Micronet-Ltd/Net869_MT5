# IAR project ksdk_mqx_20d100m_lib.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK20DX256xxx10 Freescale MK20DX256xxx10
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: DEBUG; CPU_MK20DX256VMC10; FSL_RTOS_MQX
  ICCARM.CCDiagSuppress: Pa039,Pe068,Pe069,Pa082,Pe177,Pe186,Pe550,Pa050
  ICCARM.CCIncludePath2: ..\..\BSP\rtos\mqx\mqx\source\psp\cortex_m\compiler\iar; ..\..\BSP\rtos; ..\..\BSP\rtos\mqx\config\common; ..\..\rtos\mqx\config\mcu\MK20D10; ..\..\BSP\rtos\mqx\mqx\source\include; ..\..\BSP\rtos\mqx\mqx\source\psp\cortex_m; ..\..\BSP\platform\CMSIS\Include; ..\..\BSP\platform\devices; ..\..\BSP\platform\devices\MK20D10\include; ..\..\BSP\platform\devices\MK20D10\startup; ..\..\BSP\platform\utilities\inc; ..\..\BSP\platform\hal\inc; ..\..\BSP\platform\drivers\inc; ..\..\BSP\platform\system\inc; ..\..\BSP\platform\osa\inc; ..\..\..\MCU_TASKS\Sources\FlexCAN
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.ADefines: DEBUG
  ILINK.IlinkOutputFile: ksdk_mqx_lib.out
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_MK20DX256VMC10; FSL_RTOS_MQX
  ICCARM.CCIncludePath2: ..\..\BSP\rtos\mqx\mqx\source\psp\cortex_m\compiler\iar; ..\..\BSP\rtos; ..\..\BSP\rtos\mqx\config\common; ..\..\rtos\mqx\config\mcu\MK20D10; ..\..\BSP/rtos/mqx/mqx/source/include; ..\..\BSP/rtos/mqx/mqx/source/psp/cortex_m; ..\..\BSP/platform/CMSIS/Include; ..\..\BSP/platform/devices; ..\..\BSP/platform/devices/MK20D10/include; ..\..\BSP/platform/devices/MK20D10/startup; ..\..\BSP/platform/utilities/inc; ..\..\BSP/platform/hal/inc; ..\..\BSP/platform/drivers/inc; ..\..\BSP/platform/system/inc; ..\..\BSP/platform/osa/inc; ..\..\..\MCU_TASKS\Sources\FlexCAN
  ICCARM.CCOptLevel: 3
  ILINK.IlinkOutputFile: libgeneric.out
  group osa
    ../../BSP/platform/osa/inc/: fsl_os_abstraction.h fsl_os_abstraction_mqx.h
    ../../BSP/platform/osa/src/: fsl_os_abstraction_mqx.c
  group platform/adc16/drivers
    ../../BSP/platform/drivers/src/adc16/: fsl_adc16_common.c fsl_adc16_driver.c
    ../../BSP/platform/drivers/inc/: fsl_adc16_driver.h
  group platform/adc16/hal
    ../../BSP/platform/hal/src/adc16/: fsl_adc16_hal.c
    ../../BSP/platform/hal/inc/: fsl_adc16_hal.h
  group platform/clock/system
    ../../BSP/platform/system/src/clock/: fsl_clock_manager.c fsl_clock_manager_common.c
    ../../BSP/platform/system/inc/: fsl_clock_manager.h
    ../../BSP/platform/system/src/clock/MK20D10/: fsl_clock_MK20D10.c fsl_clock_MK20D10.h
  group platform/cmp/drivers
    ../../BSP/platform/drivers/src/cmp/: fsl_cmp_common.c fsl_cmp_driver.c
    ../../BSP/platform/drivers/inc/: fsl_cmp_driver.h
  group platform/cmp/hal
    ../../BSP/platform/hal/src/cmp/: fsl_cmp_hal.c
    ../../BSP/platform/hal/inc/: fsl_cmp_hal.h
  group platform/cmt/drivers
    ../../BSP/platform/drivers/src/cmt/: fsl_cmt_common.c fsl_cmt_driver.c
    ../../BSP/platform/drivers/inc/: fsl_cmt_driver.h
  group platform/cmt/hal
    ../../BSP/platform/hal/src/cmt/: fsl_cmt_hal.c
    ../../BSP/platform/hal/inc/: fsl_cmt_hal.h
  group platform/crc/drivers
    ../../BSP/platform/drivers/src/crc/: fsl_crc_common.c fsl_crc_driver.c
    ../../BSP/platform/drivers/inc/: fsl_crc_driver.h
  group platform/crc/hal
    ../../BSP/platform/hal/src/crc/: fsl_crc_hal.c
    ../../BSP/platform/hal/inc/: fsl_crc_hal.h
  group platform/dac/drivers
    ../../BSP/platform/drivers/src/dac/: fsl_dac_common.c fsl_dac_driver.c
    ../../BSP/platform/drivers/inc/: fsl_dac_driver.h
  group platform/dac/hal
    ../../BSP/platform/hal/src/dac/: fsl_dac_hal.c
    ../../BSP/platform/hal/inc/: fsl_dac_hal.h
  group platform/dmamux/hal
    ../../BSP/platform/hal/src/dmamux/: fsl_dmamux_hal.c
    ../../BSP/platform/hal/inc/: fsl_dmamux_hal.h
  group platform/dspi/drivers
    ../../BSP/platform/drivers/src/dspi/: fsl_dspi_common.c fsl_dspi_edma_shared_function.c fsl_dspi_shared_function.c
    ../../BSP/platform/drivers/inc/: fsl_dspi_edma_shared_function.h fsl_dspi_shared_function.h
  group platform/dspi/drivers/master
    ../../BSP/platform/drivers/src/dspi/: fsl_dspi_edma_master_driver.c fsl_dspi_master_driver.c
    ../../BSP/platform/drivers/inc/: fsl_dspi_edma_master_driver.h fsl_dspi_master_driver.h
  group platform/dspi/drivers/slave
    ../../BSP/platform/drivers/src/dspi/: fsl_dspi_edma_slave_driver.c fsl_dspi_slave_driver.c
    ../../BSP/platform/drivers/inc/: fsl_dspi_edma_slave_driver.h fsl_dspi_slave_driver.h
  group platform/dspi/hal
    ../../BSP/platform/hal/src/dspi/: fsl_dspi_hal.c
    ../../BSP/platform/hal/inc/: fsl_dspi_hal.h
  group platform/edma/drivers
    ../../BSP/platform/drivers/src/edma/: fsl_edma_common.c fsl_edma_driver.c
    ../../BSP/platform/drivers/inc/: fsl_edma_driver.h fsl_edma_request.h
  group platform/edma/hal
    ../../BSP/platform/hal/src/edma/: fsl_edma_hal.c
    ../../BSP/platform/hal/inc/: fsl_edma_hal.h
  group platform/ewm/drivers
    ../../BSP/platform/drivers/src/ewm/: fsl_ewm_common.c fsl_ewm_driver.c
    ../../BSP/platform/drivers/inc/: fsl_ewm_driver.h
  group platform/ewm/hal
    ../../BSP/platform/hal/src/ewm/: fsl_ewm_hal.c
    ../../BSP/platform/hal/inc/: fsl_ewm_hal.h
  group platform/flash
    ../../BSP/platform/drivers/src/flash/: fsl_flash_lpm_callback.c
  group platform/flash/C90TFS/drvsrc/include
    ../../BSP/platform/drivers/src/flash/C90TFS/drvsrc/include/: FTFx_KX_flash_config.h SSD_FTFx.h SSD_FTFx_Common.h SSD_FTFx_Internal.h SSD_Types.h
  group platform/flash/C90TFS/drvsrc/source
    ../../BSP/platform/drivers/src/flash/C90TFS/drvsrc/source/: CopyToRam.c DEFlashPartition.c DFlashGetProtection.c DFlashSetProtection.c EEEWrite.c EERAMGetProtection.c EERAMSetProtection.c FlashCheckSum.c FlashCommandSequence.c FlashEraseAllBlock.c FlashEraseAllBlockUnsecure.c FlashEraseBlock.c FlashEraseResume.c FlashEraseSector.c FlashEraseSuspend.c FlashGetSecurityState.c FlashInit.c FlashProgram.c FlashProgramCheck.c FlashProgramOnce.c FlashProgramSection.c FlashReadOnce.c FlashReadResource.c FlashSecurityBypass.c FlashVerifyAllBlock.c FlashVerifyBlock.c FlashVerifySection.c PFlashFacGetSAProtection.c PFlashFacGetXAProtection.c PFlashGetProtection.c PFlashSetProtection.c PFlashSwap.c PFlashSwapCtl.c SetEEEEnable.c
  group platform/flexbus
    ../../BSP/platform/drivers/src/flexbus/: fsl_flexbus_common.c
  group platform/flexbus/drivers
    ../../BSP/platform/drivers/src/flexbus/: fsl_flexbus_driver.c
    ../../BSP/platform/drivers/inc/: fsl_flexbus_driver.h
  group platform/flexbus/hal
    ../../BSP/platform/hal/src/flexbus/: fsl_flexbus_hal.c
    ../../BSP/platform/hal/inc/: fsl_flexbus_hal.h
  group platform/flexcan/drivers
    ../../BSP/platform/drivers/src/flexcan/: fsl_flexcan_common.c fsl_flexcan_driver.c
    ../../BSP/platform/drivers/inc/: fsl_flexcan_driver.h
  group platform/flexcan/hal
    ../../BSP/platform/hal/src/flexcan/: fsl_flexcan_hal.c
    ../../BSP/platform/hal/inc/: fsl_flexcan_hal.h
  group platform/ftm/drivers
    ../../BSP/platform/drivers/src/ftm/: fsl_ftm_common.c fsl_ftm_driver.c
    ../../BSP/platform/drivers/inc/: fsl_ftm_driver.h
  group platform/ftm/hal
    ../../BSP/platform/hal/src/ftm/: fsl_ftm_hal.c
    ../../BSP/platform/hal/inc/: fsl_ftm_hal.h
  group platform/gpio/drivers
    ../../BSP/platform/drivers/src/gpio/: fsl_gpio_common.c fsl_gpio_driver.c
    ../../BSP/platform/drivers/inc/: fsl_gpio_driver.h
  group platform/gpio/hal
    ../../BSP/platform/hal/src/gpio/: fsl_gpio_hal.c
    ../../BSP/platform/hal/inc/: fsl_gpio_hal.h
  group platform/hwtimer/system
    ../../BSP/platform/system/src/hwtimer/: fsl_hwtimer.c fsl_hwtimer_pit.c fsl_hwtimer_systick.c
    ../../BSP/platform/system/inc/: fsl_hwtimer.h fsl_hwtimer_pit.h fsl_hwtimer_systick.h
  group platform/i2c/drivers
    ../../BSP/platform/drivers/src/i2c/: fsl_i2c_common.c fsl_i2c_shared_function.c
    ../../BSP/platform/drivers/inc/: fsl_i2c_shared_function.h
  group platform/i2c/drivers/master
    ../../BSP/platform/drivers/src/i2c/: fsl_i2c_master_driver.c
    ../../BSP/platform/drivers/inc/: fsl_i2c_master_driver.h
  group platform/i2c/drivers/slave
    ../../BSP/platform/drivers/src/i2c/: fsl_i2c_slave_driver.c
    ../../BSP/platform/drivers/inc/: fsl_i2c_slave_driver.h
  group platform/i2c/hal
    ../../BSP/platform/hal/src/i2c/: fsl_i2c_hal.c
    ../../BSP/platform/hal/inc/: fsl_i2c_hal.h
  group platform/interrupt/system
    ../../BSP/platform/system/src/interrupt/: fsl_interrupt_manager.c
    ../../BSP/platform/system/inc/: fsl_interrupt_manager.h
  group platform/llwu/hal
    ../../BSP/platform/hal/src/llwu/: fsl_llwu_hal.c
    ../../BSP/platform/hal/inc/: fsl_llwu_hal.h
  group platform/lptmr/drivers
    ../../BSP/platform/drivers/src/lptmr/: fsl_lptmr_common.c fsl_lptmr_driver.c
    ../../BSP/platform/drivers/inc/: fsl_lptmr_driver.h
  group platform/lptmr/hal
    ../../BSP/platform/hal/src/lptmr/: fsl_lptmr_hal.c
    ../../BSP/platform/hal/inc/: fsl_lptmr_hal.h
  group platform/mcg/hal
    ../../BSP/platform/hal/src/mcg/: fsl_mcg_hal.c fsl_mcg_hal_modes.c
    ../../BSP/platform/hal/inc/: fsl_mcg_hal.h fsl_mcg_hal_modes.h
  group platform/mpu/drivers
    ../../BSP/platform/drivers/src/mpu/: fsl_mpu_common.c fsl_mpu_driver.c
    ../../BSP/platform/drivers/inc/: fsl_mpu_driver.h
  group platform/mpu/hal
    ../../BSP/platform/hal/src/mpu/: fsl_mpu_hal.c
    ../../BSP/platform/hal/inc/: fsl_mpu_hal.h
  group platform/osc/hal
    ../../BSP/platform/hal/src/osc/: fsl_osc_hal.c
    ../../BSP/platform/hal/inc/: fsl_osc_hal.h
  group platform/pdb/drivers
    ../../BSP/platform/drivers/src/pdb/: fsl_pdb_common.c fsl_pdb_driver.c
    ../../BSP/platform/drivers/inc/: fsl_pdb_driver.h
  group platform/pdb/hal
    ../../BSP/platform/hal/src/pdb/: fsl_pdb_hal.c
    ../../BSP/platform/hal/inc/: fsl_pdb_hal.h
  group platform/pit/drivers
    ../../BSP/platform/drivers/src/pit/: fsl_pit_common.c fsl_pit_driver.c
    ../../BSP/platform/drivers/inc/: fsl_pit_driver.h
  group platform/pit/hal
    ../../BSP/platform/hal/src/pit/: fsl_pit_hal.c
    ../../BSP/platform/hal/inc/: fsl_pit_hal.h
  group platform/pmc/hal
    ../../BSP/platform/hal/inc/: fsl_pmc_hal.h
  group platform/port/hal
    ../../BSP/platform/hal/src/port/: fsl_port_hal.c
    ../../BSP/platform/hal/inc/: fsl_port_hal.h
  group platform/power/system
    ../../BSP/platform/system/src/power/: fsl_power_manager.c fsl_power_manager_common.h
    ../../BSP/platform/system/inc/: fsl_power_manager.h
  group platform/rcm/hal
    ../../BSP/platform/hal/src/rcm/: fsl_rcm_hal.c
    ../../BSP/platform/hal/inc/: fsl_rcm_hal.h
  group platform/rnga/hal
    ../../BSP/platform/hal/src/rnga/: fsl_rnga_hal.c
    ../../BSP/platform/hal/inc/: fsl_rnga_hal.h
  group platform/rtc/drivers
    ../../BSP/platform/drivers/src/rtc/: fsl_rtc_common.c fsl_rtc_driver.c
    ../../BSP/platform/drivers/inc/: fsl_rtc_driver.h
  group platform/rtc/hal
    ../../BSP/platform/hal/src/rtc/: fsl_rtc_hal.c
    ../../BSP/platform/hal/inc/: fsl_rtc_hal.h
  group platform/sai/drivers
    ../../BSP/platform/drivers/src/sai/: fsl_sai_common.c fsl_sai_driver.c
    ../../BSP/platform/drivers/inc/: fsl_sai_driver.h
  group platform/sai/hal
    ../../BSP/platform/hal/src/sai/: fsl_sai_hal.c
    ../../BSP/platform/hal/inc/: fsl_sai_hal.h
  group platform/sdhc/drivers
    ../../BSP/platform/drivers/inc/: fsl_sdhc.h fsl_sdhc_driver.h
    ../../BSP/platform/drivers/src/sdhc/: fsl_sdhc_common.c fsl_sdhc_driver.c
    ../../BSP/platform/composite/inc/: fsl_sdmmc_card.h
  group platform/sdhc/hal
    ../../BSP/platform/hal/src/sdhc/: fsl_sdhc_hal.c
    ../../BSP/platform/hal/inc/: fsl_sdhc_hal.h
  group platform/sim/hal
    ../../BSP/platform/hal/inc/: fsl_sim_hal.h
    ../../BSP/platform/hal/src/sim/MK20D10/: fsl_sim_hal_MK20D10.c fsl_sim_hal_MK20D10.h
  group platform/smc/hal
    ../../BSP/platform/hal/src/smc/: fsl_smc_hal.c
    ../../BSP/platform/hal/inc/: fsl_smc_hal.h
  group platform/tsi/drivers
    ../../BSP/platform/drivers/src/tsi/: fsl_tsi_common.c fsl_tsi_driver.c fsl_tsi_v2_driver_specific.c
    ../../BSP/platform/drivers/inc/: fsl_tsi_driver.h
  group platform/tsi/hal
    ../../BSP/platform/hal/src/tsi/: fsl_tsi_hal.c fsl_tsi_v2_hal_specific.c
    ../../BSP/platform/hal/inc/: fsl_tsi_hal.h fsl_tsi_v2_hal_specific.h
  group platform/uart/drivers
    ../../BSP/platform/drivers/src/uart/: fsl_uart_common.c fsl_uart_driver.c fsl_uart_edma_driver.c
    ../../BSP/platform/drivers/inc/: fsl_uart_driver.h fsl_uart_edma_driver.h
  group platform/uart/hal
    ../../BSP/platform/hal/src/uart/: fsl_uart_hal.c
    ../../BSP/platform/hal/inc/: fsl_uart_hal.h
  group platform/vref/drivers
    ../../BSP/platform/drivers/src/vref/: fsl_vref_common.c fsl_vref_driver.c
    ../../BSP/platform/drivers/inc/: fsl_vref_driver.h
  group platform/vref/hal
    ../../BSP/platform/hal/src/vref/: fsl_vref_hal.c
    ../../BSP/platform/hal/inc/: fsl_vref_hal.h
  group platform/wdog/drivers
    ../../BSP/platform/drivers/src/wdog/: fsl_wdog_common.c fsl_wdog_driver.c
    ../../BSP/platform/drivers/inc/: fsl_wdog_driver.h
  group platform/wdog/hal
    ../../BSP/platform/hal/src/wdog/: fsl_wdog_hal.c
    ../../BSP/platform/hal/inc/: fsl_wdog_hal.h
