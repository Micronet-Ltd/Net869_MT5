# IAR project NET869_MCU.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK20DX256xxx10 Freescale MK20DX256xxx10
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: _DEBUG=1; CPU_MK20DX256VMC10=1; FSL_RTOS_MQX=1; TWR_K60D100M; TOWER
  ICCARM.CCDiagSuppress: Pa039,Pe068,Pe069,Pa082,Pe177,Pe186,Pe550,Pa050
  ICCARM.CCIncludePath2: ../../MQX_OS/rtos/mqx/config/mcu/MK20D10; ../../MQX_OS/rtos/mqx/config/board/net869/; ..\..\MQX_OS\rtos\mqx\config\board\net869; ..\..\MQX_OS\rtos\mqx\config\mcu\MK20D10; ..\..\MQX_OS\BSP\rtos\mqx\mqx\source\include; ..\..\MQX_OS\BSP\rtos\mqx\mqx_stdlib\source\include; ../../MQX_OS/BSP/rtos/mqx/config/common; ../../MQX_OS/BSP/rtos/mqx/mqx/source/bsp; ../../MQX_OS/BSP/rtos/mqx/mqx/source/include; ..\..\MQX_OS\BSP\rtos\mqx\mqx\source\psp\cortex_m\cpu; ..\..\MQX_OS\BSP\rtos\mqx\mqx\source\psp\cortex_m\core\M4; ..\..\MQX_OS\BSP\rtos\mqx\mqx\source\psp\cortex_m\compiler\iar; ..\..\MQX_OS\BSP\rtos\mqx\mqx\source\psp\cortex_m; ..\..\MQX_OS\BSP\rtos\mqx\mqx\source\nio; ..\..\MQX_OS\BSP\rtos\mqx\mqx\source\nio\drivers\nio_serial; ..\..\MQX_OS\BSP\rtos\mqx\mqx_stdlib\source\stdio; ..\..\MQX_OS\BSP\rtos\mqx\mqx\source\nio\drivers\nio_tty; ..\..\MQX_OS\BSP\rtos\mqx\mqx\source\nio\drivers\nio_dummy; ../../MQX_OS/BSP/platform/drivers/inc; ../../MQX_OS/BSP/platform/drivers/src/uart; ../../MQX_OS/BSP/platform/drivers/src/gpio; ../../MQX_OS/BSP/platform/drivers/src/pit; ../../MQX_OS/BSP/platform/drivers/src/edma; ../../MQX_OS/BSP/platform/system/inc; ../../MQX_OS/BSP/platform/osa/inc; ../../MQX_OS/BSP/rtos; ../../MQX_OS/BSP/platform/utilities/inc; ../../MQX_OS/BSP/platform/CMSIS/Include; ../../MQX_OS/BSP/platform/devices; ../../MQX_OS/BSP/platform/devices/MK20D10/include; ../../MQX_OS/BSP/platform/devices/MK20D10/startup; ..\..\MQX_OS\BSP\platform\CMSIS\Include; ..\..\MQX_OS\usb\usb_core\device\include\net869; ..\..\MQX_OS\usb\usb_core\device\sources\bsp\net869; ../../MQX_OS/BSP/usb/adapter/sources; ../../MQX_OS/BSP/usb/adapter/sources/sdk; ../../MQX_OS/BSP/usb/usb_core/device/include/MK60D10; ../../MQX_OS/BSP/usb/usb_core/device/include; ../../MQX_OS/BSP/usb/usb_core/device/sources/classes/audio; ../../MQX_OS/BSP/usb/usb_core/device/sources/classes/cdc; ../../MQX_OS/BSP/usb/usb_core/device/sources/classes/common; ../../MQX_OS/BSP/usb/usb_core/device/sources/classes/composite; ../../MQX_OS/BSP/usb/usb_core/device/sources/classes/hid; ../../MQX_OS/BSP/usb/usb_core/device/sources/classes/include; ../../MQX_OS/BSP/usb/usb_core/device/sources/classes/include/config; ../../MQX_OS/BSP/usb/usb_core/device/sources/classes/msd; ../../MQX_OS/BSP/usb/usb_core/device/sources/classes/phdc; ../../MQX_OS/BSP/usb/usb_core/device/sources/classes/video; ../../MQX_OS/BSP/usb/usb_core/device/sources/controller/khci; ../../MQX_OS/BSP/usb/usb_core/device/sources/controller; ../../MQX_OS/BSP/usb/usb_core/hal; ../../MQX_OS/BSP/usb/usb_core/include; ../..; ../../MQX_OS/BSP/platform/system/inc; ../../MQX_OS/BSP/platform/hal/inc; ../../MQX_OS/BSP/platform/drivers/inc; ../../MQX_OS/BSP/platform/drivers/src/mpu; ../../MQX_OS/BSP/platform/startup; ..\Sources\FlexCAN; ..\Sources\FPGA_API; ..\Sources\J1708; ..\Sources\POWER_MGM; ..\Sources\accel; ..\Sources\ADC; ..\Sources\EXT_GPIOS; ..\Sources\USB; ..\Sources\rtc; ..\Sources; ..\Board_Files; ..\Sources\C90TFS\drvsrc\include; ..\Sources\watchdog; ..\Sources\one_wire
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG; CPU_MK20DX256VLQ10=1
  AARM.AUserIncludes: ..\..\MQX_OS\BSP\platform\devices\MK20D10\startup\iar; ..\..\MQX_OS\BSP\platform\devices
  OBJCOPY.OOCOutputFile: NET869_MCU.srec
  ILINK.IlinkOutputFile: NET869_MCU.out
  ILINK.IlinkConfigDefines: __ram_vector_table__=1; __stack_size__=0x800; __heap_size__=0x4000
  ILINK.IlinkIcfFile: C:\Users\abid.esmail\Documents\micronet\source\Net869_MT5\MCU_TASKS\linker\MK20DX256xxx10_flash.icf
  ILINK.IlinkAdditionalLibs: ..\..\MQX_OS\MQX_PSP\iar\Debug_IAR\lib_mqx.a; ..\..\MQX_OS\MQX_LIB\iar\Debug_IAR\libksdk_mqx_lib.a; ..\..\MQX_OS\MQX_STDLIB\iar\Debug_IAR\lib_mqx_stdlib.a; ..\..\MQX_OS\MQX_USB_DEVICE\iar\Debug_IAR\libusbd_mqx.a
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: _DEBUG=0; CPU_MK20DX256VMC10; FSL_RTOS_MQX; TWR_K60D100M; TOWER
  ICCARM.CCIncludePath2: ../../MQX_OS/rtos/mqx/config/mcu/MK20D10; ../../MQX_OS/rtos/mqx/config/board/net869/; ..\..\MQX_OS\rtos\mqx\config\board\net869; ..\..\MQX_OS\rtos\mqx\config\mcu\MK20D10; ..\..\MQX_OS\BSP\rtos\mqx\mqx\source\include; ..\..\MQX_OS\BSP\rtos\mqx\mqx_stdlib\source\include; ../../MQX_OS/BSP/rtos/mqx/config/common; ../../MQX_OS/BSP/rtos/mqx/mqx/source/bsp; ../../MQX_OS/BSP/rtos/mqx/mqx/source/include; ..\..\MQX_OS\BSP\rtos\mqx\mqx\source\psp\cortex_m\cpu; ..\..\MQX_OS\BSP\rtos\mqx\mqx\source\psp\cortex_m\core\M4; ..\..\MQX_OS\BSP\rtos\mqx\mqx\source\psp\cortex_m\compiler\iar; ..\..\MQX_OS\BSP\rtos\mqx\mqx\source\psp\cortex_m; ..\..\MQX_OS\BSP\rtos\mqx\mqx\source\nio; ..\..\MQX_OS\BSP\rtos\mqx\mqx\source\nio\drivers\nio_serial; ..\..\MQX_OS\BSP\rtos\mqx\mqx_stdlib\source\stdio; ..\..\MQX_OS\BSP\rtos\mqx\mqx\source\nio\drivers\nio_tty; ..\..\MQX_OS\BSP\rtos\mqx\mqx\source\nio\drivers\nio_dummy; ../../MQX_OS/BSP/platform/drivers/inc; ../../MQX_OS/BSP/platform/drivers/src/uart; ../../MQX_OS/BSP/platform/drivers/src/gpio; ../../MQX_OS/BSP/platform/drivers/src/pit; ../../MQX_OS/BSP/platform/drivers/src/edma; ../../MQX_OS/BSP/platform/system/inc; ../../MQX_OS/BSP/platform/osa/inc; ../../MQX_OS/BSP/rtos; ../../MQX_OS/BSP/platform/utilities/inc; ../../MQX_OS/BSP/platform/CMSIS/Include; ../../MQX_OS/BSP/platform/devices; ../../MQX_OS/BSP/platform/devices/MK20D10/include; ../../MQX_OS/BSP/platform/devices/MK20D10/startup; ..\..\MQX_OS\BSP\platform\CMSIS\Include; ..\..\MQX_OS\usb\usb_core\device\include\net869; ..\..\MQX_OS\usb\usb_core\device\sources\bsp\net869; ../../MQX_OS/BSP/usb/adapter/sources; ../../MQX_OS/BSP/usb/adapter/sources/sdk; ../../MQX_OS/BSP/usb/usb_core/device/include/MK60D10; ../../MQX_OS/BSP/usb/usb_core/device/include; ../../MQX_OS/BSP/usb/usb_core/device/sources/classes/audio; ../../MQX_OS/BSP/usb/usb_core/device/sources/classes/cdc; ../../MQX_OS/BSP/usb/usb_core/device/sources/classes/common; ../../MQX_OS/BSP/usb/usb_core/device/sources/classes/composite; ../../MQX_OS/BSP/usb/usb_core/device/sources/classes/hid; ../../MQX_OS/BSP/usb/usb_core/device/sources/classes/include; ../../MQX_OS/BSP/usb/usb_core/device/sources/classes/include/config; ../../MQX_OS/BSP/usb/usb_core/device/sources/classes/msd; ../../MQX_OS/BSP/usb/usb_core/device/sources/classes/phdc; ../../MQX_OS/BSP/usb/usb_core/device/sources/classes/video; ../../MQX_OS/BSP/usb/usb_core/device/sources/controller/khci; ../../MQX_OS/BSP/usb/usb_core/device/sources/controller; ../../MQX_OS/BSP/usb/usb_core/hal; ../../MQX_OS/BSP/usb/usb_core/include; ../..; ../../MQX_OS/BSP/platform/system/inc; ../../MQX_OS/BSP/platform/hal/inc; ../../MQX_OS/BSP/platform/drivers/inc; ../../MQX_OS/BSP/platform/drivers/src/mpu; ../../MQX_OS/BSP/platform/startup; ..\Sources\FlexCAN; ..\Sources\FPGA_API; ..\Sources\J1708; ..\Sources\POWER_MGM; ..\Sources\accel; ..\Sources\ADC; ..\Sources\EXT_GPIOS; ..\Sources\USB; ..\Sources; ..\Board_Files; ..\Sources\ADC; ..\Sources\C90TFS\drvsrc\include; ..\Sources\EXT_GPIOS; ..\..\MQX_OS; ..\startup; ..\Sources\rtc; ..\Sources\watchdog
  ICCARM.CCOptLevel: 3
  ILINK.IlinkIcfFile: ..\linker\MK20DX256xxx10_flash.icf
  ILINK.IlinkAdditionalLibs: ..\..\MQX_OS\MQX_USB_DEVICE\iar\Release_IAR\libusbd_mqx.a; ..\..\MQX_OS\MQX_PSP\iar\Release_IAR\lib_mqx.a; ..\..\MQX_OS\MQX_LIB\iar\Release_IAR\libksdk_platform_mqx.a; ..\..\MQX_OS\MQX_STDLIB\iar\Release_IAR\lib_mqx_stdlib.a
  group board
    ../Board_Files/: board.c board.h gpio_pins.c gpio_pins.h pin_mux.c pin_mux.h Uart_debugTerminal.c Uart_debugTerminal.h
  group BSP Files
    ../../MQX_OS/BSP/rtos/mqx/mqx/source/bsp/: bsp.h bsp_config.h init_bsp.c
    ../../MQX_OS/BSP/rtos/mqx/mqx/source/include/: mqx.h
    ../../MQX_OS/rtos/mqx/mqx/source/bsp/: mqx_main.c
  group Config Files
    ../../MQX_OS/rtos/mqx/config/mcu/MK20D10/: mqx_sdk_config.h
    ../../MQX_OS/rtos/mqx/config/board/net869/: user_config.h
  group Config Files/Common
    ../../MQX_OS/BSP/rtos/mqx/config/common/: lite_config.h mqx_cnfg.h small_ram_config.h verif_enabled_config.h
  group sources
    ../Sources/: i2c_configuration.c i2c_configuration.h main_tasks.c mic_typedef.h tasks_list.c tasks_list.h uart_configuration.c uart_configuration.h version.h
  group sources/accel
    ../Sources/accel/: acc_task.c acc_task.h
  group sources/ADC
    ../Sources/ADC/: ADC.c ADC.h
  group sources/C90TFS/inc
    ../Sources/C90TFS/drvsrc/include/: FTFx_KX_flash_config.h SSD_FTFx.h SSD_FTFx_Common.h SSD_FTFx_Internal.h SSD_Types.h
  group sources/C90TFS/src
    ../Sources/C90TFS/drvsrc/source/: DFlashGetProtection.c FlashCommandSequence.c FlashEraseSector.c FlashInit.c FlashProgram.c PFlashGetProtection.c SetEEEEnable.c
  group sources/EXT_GPIOS
    ../Sources/EXT_GPIOS/: EXT_GPIOS.c EXT_GPIOS.h
  group sources/FlexCan
    ../Sources/FlexCAN/: FlexCanDevice.c FlexCanDevice.h FlexCanDevice_IRQ.c FlexCanMsg_queue.c FlexCanMsg_queue.h
  group sources/FPGA_API
    ../Sources/FPGA_API/: fpga_API.c fpga_API.h
  group sources/J1708
    ../Sources/J1708/: J1708_task.c J1708_task.h
  group sources/one_wire
    ../Sources/one_wire/: one_wire_task.c one_wire_task.h
  group sources/POWER_MGM
    ../Sources/POWER_MGM/: Device_control_GPIO.c Device_control_GPIO.h power_mgm.c power_mgm.h Wiggle_sensor.c Wiggle_sensor.h
  group sources/rtc
    ../Sources/rtc/: rtc.c rtc.h
  group sources/Update
    ../Sources/Update/SRC/: flash_funcs.c flash_funcs.h fpga_funcs.c spi_settings.h uart.c update_exec.c updater.c updater.h W25X40CL.h
  group sources/USB
    ../Sources/USB/: command.c command.h control_task.c control_task.h frame.c frame.h protocol.c protocol.h usb_descriptor.c usb_descriptor.h virtual_com.c virtual_com.h
  group sources/watchdog
    ../Sources/watchdog/: watchdog_mgmt.c watchdog_mgmt.h
  group utilities/Debug_console
    ../../MQX_OS/BSP/platform/utilities/src/: fsl_debug_console.c fsl_misc_utilities.c print_scan.c print_scan.h
    ../../MQX_OS/BSP/platform/utilities/inc/: fsl_debug_console.h fsl_misc_utilities.h
